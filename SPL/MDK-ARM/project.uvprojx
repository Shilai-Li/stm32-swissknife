# Keil uVision project project.uvprojx, settings and files
target project (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Core\Inc;..\Drivers\CMSIS\CM3\CoreSupport;..\Drivers\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\User\App\Inc;..\User\Drivers\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core/Inc
    ../Core/Inc/: main.h stm32f10x_conf.h stm32f10x_it.h tim.h spi.h gpio.h
  group Core/Src
    ../Core/Src/: main.c stm32f10x_it.c tim.c spi.c gpio.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Drivers/STM32F10x_StdPeriph_Driver
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User/App/Inc
    ../User/App/Inc/: app.h
  group User/App/Src
    ../User/App/Src/: app.c
  group User/Drivers/Inc
    ../User/Drivers/Inc/: buzzer_driver.h delay_driver.h dht11_driver.h led_driver.h ssd1306.h ssd1306_conf.h ssd1306_fonts.h ssd1306_tests.h uart_driver.h
  group User/Drivers/Src
    ../User/Drivers/Src/: buzzer_driver.c delay_driver.c dht11_driver.c led_driver.c ssd1306.c ssd1306_fonts.c ssd1306_tests.c uart_driver.c
